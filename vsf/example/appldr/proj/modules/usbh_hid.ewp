# IAR project usbh_hid.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: VSF_STANDALONE_MODULE; MODULE_NAME="vsf.stack.usb.host.hid"; MODULE_INIT=vsfusbh_hid_modinit; MODULE_EXIT=vsfusbh_hid_modexit
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\cortex-m
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: MODULE_SIZE=0x1000; MODULE_NAME="vsf.stack.usb.host.hid"
  OBJCOPY.OOCOutputFile: usbh_hid.bin
  postbuild: wscript fixsize.vbs $EXE_DIR$\$PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkIcfFile: module.icf
  ILINK.IlinkProgramEntryLabel: module_entry
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; VSF_STANDALONE_MODULE; MODULE_NAME="vsf.stack.usb.host.hid"; MODULE_INIT=vsfusbh_hid_modinit; MODULE_EXIT=vsfusbh_hid_modexit
  group (top)
    ./: app_cfg.h interfaces_cfg.h vsf_cfg.h
    ../../: app_hw_cfg.h
    ../../module/: modmain.c
  group vsf/interfaces/cpu/cortex-m/startup
    ../../../../interfaces/cpu/cortex-m/startup/iar/: startup.s
  group vsf/stack/usb/class/host/HID
    ../../../../stack/usb/class/host/HID/: vsfusbh_HID.c
