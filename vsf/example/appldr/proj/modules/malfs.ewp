# IAR project malfs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: VSF_STANDALONE_MODULE; MODULE_NAME="vsf.component.file.fs.malfs"; MODULE_INIT=vsf_malfs_modinit; MODULE_EXIT=vsf_malfs_modexit
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\cortex-m
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: MODULE_SIZE=0x1000; MODULE_NAME="vsf.component.file.fs.malfs"
  OBJCOPY.OOCOutputFile: malfs.bin
  ILINK.IlinkOutputFile: malfs.out
  ILINK.IlinkIcfFile: module.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; VSF_STANDALONE_MODULE; MODULE_NAME="vsf.component.file.fs.malfs"; MODULE_INIT=vsf_malfs_modinit; MODULE_EXIT=vsf_malfs_modexit
  group (top)
    ./: app_cfg.h interfaces_cfg.h vsf_cfg.h
    ../../: app_hw_cfg.h
    ../../module/: modmain.c
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c
  group vsf/interfaces/cpu/cortex-m/startup
    ../../../../interfaces/cpu/cortex-m/startup/iar/: startup.s
