# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: VSF_STANDALONE_MODULE; MODULE_NAME="vsf.tool.fakefat32"; MODULE_INIT=fakefat32_modinit; MODULE_EXIT=fakefat32_modexit
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\cortex-m
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: MODULE_SIZE=0x1000; MODULE_NAME="vsf.tool.fakefat32"
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; VSF_STANDALONE_MODULE; MODULE_NAME="vsf.tool.fakefat32"; MODULE_INIT=fakefat32_modinit; MODULE_EXIT=fakefat32_modexit
  group (top)
    ./: app_cfg.h interfaces_cfg.h vsf_cfg.h
    ../../: app_hw_cfg.h
    ../../module/: modmain.c
  group vsf/interfaces/cpu/cortex-m/startup
    ../../../../interfaces/cpu/cortex-m/startup/iar/: startup.s
  group vsf/tool/fakefat32
    ../../../../tool/fakefat32/: fakefat32.c
