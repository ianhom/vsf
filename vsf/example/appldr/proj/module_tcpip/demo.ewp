# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VSF_STANDALONE_MODULE
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\cortex-m
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: VSF_APP_BASE=0x00000000; MODULE_SIZE=0x1000; MODULE_NAME="vsf.stack.net.tcpip"
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: app_cfg.h interfaces_cfg.h vsf_cfg.h vsf_undef.h
    ../../: app_hw_cfg.h
    ../../module/tcpip/: tcpip.c
  group vsf/interfaces/cpu/cortex-m/startup
    ../../../../interfaces/cpu/cortex-m/startup/iar/: startup.s
  group vsf/stack/tcpip
    ../../../../stack/tcpip/: vsfip.c
  group vsf/stack/tcpip/netif
    ../../../../stack/tcpip/netif/: vsfip_netif.c
  group vsf/stack/tcpip/netif/eth
    ../../../../stack/tcpip/netif/eth/: vsfip_eth.c
  group vsf/stack/tcpip/proto/dhcp
    ../../../../stack/tcpip/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcpc.c
  group vsf/stack/tcpip/proto/dns
    ../../../../stack/tcpip/proto/dns/: vsfip_dnsc.c
  group vsf/stack/tcpip/proto/http
    ../../../../stack/tcpip/proto/http/: vsfip_httpc.c
