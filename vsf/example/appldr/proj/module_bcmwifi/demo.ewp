# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: VSF_STANDALONE_MODULE; MODULE_NAME="vsf.stack.net.bcmwifi"; MODULE_INIT=bcmwifi_modinit; MODULE_EXIT=bcmwifi_modexit
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\cortex-m
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: MODULE_SIZE=0x1000; MODULE_NAME="vsf.stack.net.bcmwifi"
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; MODULE_NAME="vsf.stack.net.bcmwifi"; MODULE_INIT=bcmwifi_modinit; MODULE_EXIT=bcmwifi_modexit
  group (top)
    ./: app_cfg.h interfaces_cfg.h vsf_cfg.h
    ../../: app_hw_cfg.h
    ../../module/: modmain.c
  group vsf/interfaces/cpu/cortex-m/startup
    ../../../../interfaces/cpu/cortex-m/startup/iar/: startup.s
  group vsf/stack/tcpip/netif/eth/broadcom
    ../../../../stack/tcpip/netif/eth/broadcom/: bcm_sdpcm.c bcm_wifi.c
  group vsf/stack/tcpip/netif/eth/broadcom/bus
    ../../../../stack/tcpip/netif/eth/broadcom/bus/: bcm_bus.c
  group vsf/stack/tcpip/netif/eth/broadcom/bus/sdio
    ../../../../stack/tcpip/netif/eth/broadcom/bus/sdio/: bcm_bus_sdio.c
  group vsf/stack/tcpip/netif/eth/broadcom/bus/spi
    ../../../../stack/tcpip/netif/eth/broadcom/bus/spi/: bcm_bus_spi.c
